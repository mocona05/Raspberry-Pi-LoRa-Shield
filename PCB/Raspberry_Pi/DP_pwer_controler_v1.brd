# Repository mocona05/Raspberry-Pi-LoRa-Shield

## EAGLE design PCB/Raspberry_Pi/DP_pwer_controler_v1.brd

Parts:
BAT1: MS621
C1, C2, C3, C4, C9, C11, C14, C16: 0.1uF; C0603
C5, C6: 12.5pF; C0603
C7, C10, C15: 4.7uF/10V; C2012/T
C8: 10nF; C0603
C12, C13: 1uF; C0603
D1: BAT54C; SOT23
F1: FSMD300R; 1812L
IC1: STM32F051XSTM32F051X; TQFP48
IC2: TPS783XX; SOT23-5L
JP1: BUTTON; MA06-1-S
JP2: SWD; 1X04M
JP3, JP5: RESET; MA02-1-MOL
JP4: RPY_BTN; MA06-1-S
L1, L2: BEAD; L0603
LED1, LED2, LED3: LEDSMD-1608; LED-1608
Q1: 32.768k; MC-306
Q2: 8MHz; CSTLA_X
Q3, Q4: DTC114EUA; SC59-BEC
Q5: CXDM4060P; SOT89
R1, R2, R3: 1k; R0603
R4, R5, R6, R10, R11, R13, R14, R17: 10k; R0603
R7, R8, R9, R15, R16: 2.2k; R0603
R12: 11k; R0603
R18: 4.7k; R0603
USB1: MOLEX-47346-0001; MOLEX-47364-0001
X1: RASPI_BOARD_B+#_F; RASPI_BOARD_B+_FULL
X2: USB-AUSB_A_FEMAIL; USB_A_FEMAIL
ZD1: SM6T6V8CAY; SMB
ZD2: RD10S; DSMM

Connections:
3V3: R15.2, R16.2, R17.2, X1.1 (3V3A), X1.17 (3V3B)
+3V3: C2.1, C9.1, C10.+, C11.1, C12.1, C14.2, C15.+, D1.G (1), IC1.24 (VDD_1), IC1.48 (VDD_2), IC2.5 (OUT), JP2.1, L2.1, R4.2, R5.2, R6.2, R10.2, R13.2, R14.2
+5V: Q5.2 (D), Q5.2@1 (D), X1.2 (5V0A), X1.4 (5V0B), X2.1 (VBUS), ZD2.C
+UB: C13.2, C16.1, F1.P$1 (1), IC2.1 (IN), IC2.3 (EN), Q5.1 (S), R18.2
AGND: C7.-, C8.2, IC1.8 (VSSA), L1.2
BTN1: C1.1, IC1.39 (PB3), R7.1
BTN2: C4.1, IC1.40 (PB4), R9.1
BTN3: C3.1, IC1.41 (PB5), R8.1
GND: BAT1.-, C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C9.2, C10.-, C11.2, C12.2, C13.1, C14.1, C15.-, C16.2, IC1.23 (VSS_1), IC1.47 (VSS2), IC2.2 (GND), IC2.4 (GND), JP1.2, JP1.4, JP1.6, JP2.3, JP3.2, JP4.2, JP4.4, JP4.6, JP5.2, L1.1, LED1.C, LED2.C, LED3.C, Q2.2 (GND), Q3.1 (GND), Q4.1 (GND), R11.2, USB1.4, X1.6 (GND_A), X1.9 (GND_B), X1.14 (GND_C), X1.20 (GND_D), X1.25 (GND_E), X1.30 (GND_F), X1.34 (GND_G), X1.39 (GND_H), X2.4 (GND), ZD1.C (K), ZD2.A
I2C2_SCL: IC1.21 (PB10), R16.1, X1.5 (SCL)
I2C2_SDA: IC1.22 (PB11), R15.1, X1.3 (SDA)
LED1: IC1.28 (PB15), R1.1
LED2: IC1.29 (PA8), R2.1
LED3: IC1.30 (PA9), R3.1
unnamed: JP1.5, R5.1, R8.2
unnamed: F1.P$2 (2), USB1.1, ZD1.A
unnamed: IC1.7 (NRST), R10.1
unnamed: JP3.1, JP5.1, Q3.3 (OUT)
unnamed: JP4.1, X1.29 (GPIO05)
unnamed: C7.+, C8.1, IC1.9 (VDDA), L2.2
unnamed: BAT1.+, D1.S (2), R12.2
unnamed: JP1.3, R6.1, R9.2
unnamed: JP4.3, X1.31 (GPIO06)
unnamed: IC1.3 (PC14=>OSC32), Q2.3 (OUT)
unnamed: JP4.5, X1.33 (GPIO13)
unnamed: IC1.44 (BOOT0), R11.1
unnamed: LED1.A, R1.2
unnamed: LED2.A, R2.2
unnamed: LED3.A, R3.2
unnamed: JP1.1, R4.1, R7.2
unnamed: Q4.3 (OUT), Q5.3 (G), R18.1
unnamed: D1.D (3), IC1.1 (BAT), R12.1
unnamed: IC1.4 (PC15<=OSC32), Q2.1 (IN)
unnamed: C6.2, IC1.5 (PF0/OSC<=), Q1.1
unnamed: C5.2, IC1.6 (PF1/OSC=>), Q1.4 (2)
RPY-RST: IC1.13 (PA3), Q3.2 (IN)
RPY_POW: IC1.45 (PB8), Q4.2 (IN)
RXI1: IC1.43 (PB7), X1.8 (TXD)
SPI1_MISO: IC1.16 (PA6), X1.19 (SPI_MOSI)
SPI1_MOSI: IC1.17 (PA7), X1.21 (SPI_MISO)
SPI1_NSS: IC1.14 (PA4), X1.24 (SPI_CE0)
SPI1_SCK: IC1.15 (PA5), X1.23 (SPI_SCLK)
SWCLK: IC1.37 (PA14), JP2.4, R14.1
SWDIO: IC1.34 (PA13), JP2.2, R13.1
TXO1: IC1.42 (PB6), X1.10 (RXD)
W-DOG: IC1.12 (PA2), R17.1, X1.40 (GPIO21)

Notes on the sheet:
POWER CONTROLER V1
https://webench.ti.com/webench5/power/webench5.cgi?app=filterarchitect&origin=ti_panel&filterType=Lowpass
POWER IN
USB POWER OUT
3.3V REGULATOR
PCM5102

Board: 2 copper layers, 65.0 x 56.0 mm, 59 parts (0 on the bottom side), 46 nets.

## EAGLE design PCB/Raspberry_Pi/Raspberry_pi_shild_v1--.brd

Parts:
C1, C2, C3, C5, C10, C17, C19, C26, C27, C28, C34, C35, C36: 0.1uF; C0603
C4, C20, C21: 10nF; C0603
C6, C9, C15: 4.7uF/10V; C3216-18/T
C7: 47uF/6.3V; C3216
C8: 10uF/35V; C3225
C11: 2.2nF/50V; C0603
C12: 0.1uF/50V; C0603
C13: 10nF/50V; C0603
C14: 10uF; C2012
C16, C18: 22uF/10V; C3216
C22, C23: 100uF; C3528-21/T
C24: 10uF; C0805
C25, C30: 1uF/10V; C0603
C29: 10uF/6V; C3216-18/T
C31, C32: 470uF; D/7343-31W
C33: 100uF/6V; C3528-21/T
C37: 4.7uF; C0805
D1, D6, D7: BAV99; SOT23
D2, D4: MBRS540T3; SMC
D3: STATUS; LED3MM
D5: LOW BAT; LED3MM
F1: 1212L200TH; 1812L
F2: 1812L110/33; 1812L
IC1: MS5611; LCP8
IC2: FDS4675; SO08
IC3: AOZ1284PI; S08-EP1
IC4: MCP73831T; SOT23-5L@1
IC5: SI4909DY; SO08-1
IC6: TPS61032PWP; R-PDSO-G16-TH_PAD
IC7: LM61BIM; SOT23
IC8: TDA2822; SO08
IC9: ADS7828E; R-PDSO-G16
J1: DC_POWER; SPC4077
J2: PJ-327; PJ-327-2
JP2: S/W; MA02-MOL-R
JP3: FET-OUT; MA03
JP4: FAN; MA02-MOL-R
JP5: ADC; MA07-1T
JP6, JP7: BAT; MA02-MOL-R
JP10: BAT; 53047-02
L1: 6.8uH; L4545
L2: 4.7uH; L4545
L3, L5: BEAD; L0603
L4: BEAD1608; L0603
LCD1: HY28B; HY28A
Q1, Q2, Q4: DTC114EUA; SC59-BEC
Q3: Si2333DDS; SOT23
R1, R2: 2.2k; R0603
R3, R8, R13, R18: 3k; R0603
R4, R23, R25: 41.2kF; R0603
R5, R9, R22, R24, R26: 10kF; R0603
R6: 47k; R0603
R7: 11k; R0603
R10: 2k; R0603
R11, R19: 1MF; R0603
R12: 200kF; R0603
R14: 100k; R0603
R15, R16, R20: 1k; R0603
R17: 0; R0603
R21: 52.3kF; R0603
R27, R28: 4.7; R0603
SJ1: LCD_5V; SJ
SJ2: O1; SJ
SW1, SW2: YST-11112E; YST-1112E
U1: HC-07; HC-06
U$1: RPI-B-V2NO_SHIELD; RPI-B-V2
VR1, VR2: 10k; R-TRIMMER-3313J
ZD1: SM6T33CAY; SMB
ZD2, ZD3: ZDSM6T24CAY; SMB

Connections:
+3V3: LCD1.20 (3V3_IN), R1.2, R2.2, U1.12 (VS), U$1.P1_1 (+3V3), U$1.P1_17 (+3V3), U$1.P5_2 (+3V3)
+5V: C14.1, C16.1, C17.1, C18.1, C19.1, C24.1, C25.1, C28.1, C29.+, D1.S (C), D5.A, IC6.13 (VOUT), IC6.14 (VOUT), IC6.15 (VOUT), IC8.2 (VDD), JP4.1, L2.1, L4.1, Q3.S (SOURCE), R18.1, R19.2, R21.2, SJ1.1, U$1.P1_2 (+5V), U$1.P1_4 (+5V), U$1.P5_1 (+5V)
+5V/1: C3.2, C26.1, C30.1, C33.+, C34.1, C37.1, D6.S (C), D7.S (C), IC1.1 (VDD), IC1.2 (PS), IC7.G (VIN), IC9.16 (VDD), JP5.6, L4.2
+12V: F2.P$2 (2), IC5.1, IC5.3, J1.3, R4.1, R8.2, R13.2, ZD2.A, ZD3.A
ADC1: IC9.2 (CH1), JP5.1
ADC2: IC9.3 (CH2), JP5.2
ADC3: IC9.4 (CH3), JP5.3
ADC4: C21.1, D7.D (AC), IC9.5 (CH4), R25.2, R26.2
ADC5: C20.1, D6.D (AC), IC9.6 (CH5), R23.2, R24.2
AGND: C22.-, C23.-, C29.-, IC8.4 (GND), J2.1, JP6.2, JP7.2, L3.2, R27.2, R28.2, VR1.1, VR2.1
BAT-V: C6.+, C9.+, IC2.1 (S), IC2.2 (S), IC2.3 (S), IC4.3 (VBAT), IC9.8 (CH7), JP2.2, R3.2, SJ2.2
BAT_CHAG: R16.1, U$1.P1_16 (GPIO23)
BL_CTRL: LCD1.40 (BL_CTRL), U$1.P1_12 (PWM0/GPIO18)
DC-IN: D2.A, F2.P$1 (1), Q4.2 (IN), ZD1.A
DC-V: C4.1, D1.D (AC), IC9.7 (CH6), R4.2, R5.2
FET_CH1: Q1.2 (IN), U$1.P1_15 (GPIO22)
FET_CH2: Q2.2 (IN), U$1.P1_13 (GPIO27)
GND: C1.2, C2.2, C4.2, C5.2, C6.-, C7.2, C8.2, C9.-, C10.2, C12.2, C14.2, C15.-, C16.2, C17.2, C18.2, C19.2, C24.2, C25.2, C28.2, D1.G (A), D4.A, IC3.3 (GND), IC4.2 (VSS), IC6.3 (PGND), IC6.4 (PGND), IC6.5 (PGND), IC6.8 (SYNC), IC6.11 (GND), IC6.TH_PAD (POW_PAD), J1.1, JP3.3, JP4.2, JP10.1, L3.1, L5.1, LCD1.2 (GND), Q1.1 (GND), Q2.1 (GND), Q4.1 (GND), R5.1, R7.1, R9.1, R10.1, R12.1, R14.2, R22.1, SW1.1, SW2.2, U1.13 (GND), U$1.P1_6 (GND), U$1.P1_9 (GND), U$1.P1_14 (GND), U$1.P1_20 (GND), U$1.P1_25 (GND), U$1.P5_7 (GND), U$1.P5_8 (GND), U$1.P6_2 (GND), ZD1.C (K)
GND1: C3.1, C20.2, C21.2, C26.2, C27.2, C30.2, C33.-, C34.2, C37.2, D6.G (A), D7.G (A), IC1.3 (GND), IC1.4 (CSB), IC1.5 (CSB1), IC7.D (GND), IC9.9 (GND), IC9.11 (COM), IC9.12 (A0), IC9.13 (A1), JP5.7, L5.2, R24.1, R26.1
GND@1: LCD1.19 (GND)
GND@2: LCD1.22 (GND)
GND@3: LCD1.39 (GND)
GPIO30: U$1.P5_5 (GPIO30)
GPIO31: U$1.P5_6 (GPIO31)
I2C0_SCL/GPIO29: U$1.P5_4 (I2C0_SCL/GPIO29)
I2C0_SDA/GPIO28: U$1.P5_3 (I2C0_SDA/GPIO28)
LCD_CS: LCD1.11 (LCD_CS), U$1.P1_24 (GPIO8/SPI0_CE0)
LCD_RST: LCD1.15 (RESET), U$1.P1_22 (GPIO25)
LCD_SCK: LCD1.13 (LCD_SCK/WR), LCD1.33 (TP_SCK), U$1.P1_23 (GPIO11/SPI0_SLCK)
LCD_SDI: LCD1.17 (TP_SDI), LCD1.34 (LCD_SDI), U$1.P1_19 (GPIO10/SPI0_MOSI)
LCD_SDO: LCD1.16 (TP_SDO), LCD1.35 (LCD_SDO), U$1.P1_21 (GPIO9/SPI0_MISO)
LEFT: J2.2, VR1.3
unnamed: C1.1, SW2.1, U$1.P1_7 (GPIO4/GPCLK0)
unnamed: C8.1, D2.C, IC3.EX_PAD (VIN), R6.2
unnamed: IC3.6 (FB), R21.1, R22.2
unnamed: C13.2, IC3.2 (BST)
unnamed: F1.P$1 (1), JP2.1, SJ2.1
unnamed: C5.1, IC2.4 (G), J1.2, R3.1
unnamed: D3.A, R15.1
unnamed: C13.1, R17.1
unnamed: D4.C, IC3.1 (LX), L2.2, R17.2
unnamed: C11.1, IC3.5 (COMP)
unnamed: C11.2, R9.2
unnamed: JP5.5, R23.1
unnamed: C2.1, SW1.2, U$1.P6_1 (RESET)
unnamed: JP5.4, R25.1
unnamed: D5.K (C), R20.2
unnamed: F1.P$2 (2), JP10.2
unnamed: IC6.7 (LBI), R11.1, R12.2
unnamed: IC3.8 (EN), R6.1, R7.2
unnamed: IC5.2, Q1.3 (OUT), R8.1
unnamed: IC3.4 (FSW), R14.1
unnamed: C27.1, IC9.10 (VREF)
unnamed: Q3.G (GATE), Q4.3 (OUT), R18.2
unnamed: C12.1, IC3.7 (SS)
unnamed: C15.+, D3.K (C), IC4.4 (VDD), Q3.D (DRAIN)
unnamed: IC4.1 (STAT), R15.2, R16.2
unnamed: C7.1, C10.1, IC2.5 (D), IC2.6 (D), IC2.7 (D), IC2.8 (D), IC6.6 (VBAT), IC6.9 (EN), L1.2, R11.2
unnamed: IC6.10 (LBO), R19.1, R20.1
unnamed: IC6.1 (SW), IC6.2 (SW), L1.1
unnamed: IC5.4, Q2.3 (OUT), R13.1
unnamed: LCD1.1 (5V_IN), SJ1.2
unnamed: IC4.5 (PROG), R10.2
unnamed: C22.+, IC8.8 (IN1-)
unnamed: C23.+, IC8.5 (IN2-)
unnamed: IC8.6 (IN2+), VR2.2
unnamed: IC8.7 (IN1+), VR1.2
unnamed: C31.+, IC8.1 (OUT1)
unnamed: C32.+, IC8.3 (OUT2)
unnamed: C31.-, C35.2, JP6.1
unnamed: C32.-, C36.2, JP7.1
unnamed: C35.1, R27.1
unnamed: C36.1, R28.1
RELAY1: IC5.5, IC5.6, JP3.1, ZD3.C (K)
RELAY2: IC5.7, IC5.8, JP3.2, ZD2.C (K)
RIGHT: J2.3, VR2.3
RXI: U1.1 (TXD), U$1.P1_10 (UART0_RXD/GPIO15)
SCL1: IC1.8 (SCLK), IC9.14 (SCL), R2.1, U$1.P1_5 (GPIO3/I2C1_SCL)
SDA1: IC1.7 (SDA), IC9.15 (SDA), R1.1, U$1.P1_3 (GPIO2/I2C1_SDA)
TEMP-V: IC7.S (VOUT), IC9.1 (CH0)
TP_CS: LCD1.32 (TP_CS), U$1.P1_26 (GPIO7/SPI0_CE1)
TP_IRQ: LCD1.36 (TP_IRQ), U$1.P1_11 (UART0_RTS/GPIO17)
TXO: U1.2 (RXD), U$1.P1_8 (UART0_TXD/GPIO14)

Notes on the sheet:
+5 Voltage Step Up Regulator
1Cell Li-po Battery Chager
SPI Touch TFT-LCD
+5 Voltage Step Down Regulator
ADDRESS: 0x77(7bit), CSB LOW
PRESSOR SENSOR
12BIT 8CH I2C-BUS ADC
MODULE
RASPBERRY PI I/O
ADDRESS: 0x48(7bit)
1W STEREO AUDIO AMP
BLUETOOTH
FET-OUT PUT
TC1047 : -40~125℃
LM61B: -30~100℃

Board: 2 copper layers, 87.0 x 56.0 mm, 113 parts (0 on the bottom side), 76 nets.

## EAGLE design PCB/Raspberry_Pi/Raspberry_pi_shild_v1.brd

Parts:
C1, C2, C3, C5, C10, C11, C12, C16, C20, C24, C25, C27, C28, C31, C52, C55: 0.1uF; C0603
C4: 4.7uF; C0805
C6, C9, C14: 4.7uF/10V; C3216-18/T
C7: 47uF/6.3V; C3216
C8: 1nF; C0603
C13: 10uF; C2012
C15, C19: 22uH/10V; C3216
C17, C18: 100uF; C3528-21/T
C21: 10uF/6V; C3216-18/T
C22, C23: 470uF; D/7343-31W
C26, C29, C30: 10nF; C0603
C51, C53: 1uF/10V; C0603
C54: 100uF/6V; C3528-21/T
C58: 10uF; C0805
D1, D6, D7: BAV99; SOT23
D2, D4: MBRS540T3; SMC
D3: STATUS; LED3MM
D5: LOW BAT; LED3MM
F1: 1812L
F2: FSMD150-2920; 1812L
IC1: ADS7828E; R-PDSO-G16
IC2: MS5611; LCP8
IC3: SHT15; SHT1X
IC4: AOZ1284PI; S08-EP1
IC5: MCP73831T; SOT23-5L@1
IC6: TPS61032; R-PDSO-G16-TH_PAD
IC7: TDA2822; SO08
IC8: IRF9335PBF; SO08
IC9: LM61; TO92-
IC10: P-CH_DUALSO-8; SO08-1
J1: DC_POWER; SPC4077
J3: PJ-327; PJ-327-2
JP1, JP2, JP3: BAT; MA02-MOL-R
JP4: S/W; MA02-MOL-R
JP5: ADC; MA07-1T
JP6: FAN; MA02-MOL-R
JP7: MA03-1SMALL; MA03-1-S
L1: 6.8uH; L4545
L2: 4.7uH; L4545
L3, L5: BEAD; L0603
L6: BEAD1608; L0603
LCD1: HY28A
Q2: Si2333DDS; SOT23
Q3: DTC114EUA; SC59-BEC
R1, R6: 3k; R0603
R2, R3, R9, R26, R27: 2.2k; R0603
R4, R22, R24: 41.2kF; R0603
R5, R19, R23, R25: 10kF; R0603
R7, R14, R17, R28: 1k; R0603
R8, R10: 100k; R0603
R11, R16: 1MF; R0603
R12: 200kF; R0603
R13: 82k; R0603
R15: 10; R0603
R18: 52.3kF; R0603
R20, R21: 4.7; R0603
SJ1: O1; SJ
SW1, SW3: YST-11112E; YST-1112E
U1: HC-07; HC-06
U$1: RPI-B-V2NO_SHIELD; RPI-B-V2
VR1, VR2: 10k; R-TRIMMER-3313J
ZD1: SM6T33CAY; SMB
ZD2, ZD3: ZDSM6T24CAY; SMB

Connections:
+3V3: C3.2, IC2.1 (VDD), IC2.2 (PS), LCD1.20 (3V3_IN), R2.2, R3.2, U1.12 (VS), U$1.P1_1 (+3V3), U$1.P1_17 (+3V3), U$1.P5_2 (+3V3)
+5V: C13.1, C15.1, C16.1, C19.1, C20.1, C21.+, C51.1, C52.1, C58.1, D1.S (C), D5.A, IC6.13 (VOUT), IC6.14 (VOUT), IC6.15 (VOUT), IC7.2 (VDD), JP6.1, L2.1, L6.1, Q2.S (SOURCE), R1.1, R16.2, R18.2, U$1.P1_2 (+5V), U$1.P1_4 (+5V), U$1.P5_1 (+5V)
+5V/1: C4.1, C5.2, C31.1, C53.1, C54.+, C55.1, D6.S (C), D7.S (C), IC1.16 (VDD), IC3.4 (VDD), IC9.3 (VIN), JP5.6, L6.2, R26.2, R27.2
+12V: F1.P$2 (2), IC10.1, IC10.3, J1.3, ZD2.A, ZD3.A
ADC0: IC1.1 (CH0), JP5.1
ADC1: IC1.2 (CH1), JP5.2
ADC2: IC1.3 (CH2), JP5.3
ADC3: C29.1, D6.D (AC), IC1.4 (CH3), R22.2, R23.2
ADC4: C30.1, D7.D (AC), IC1.5 (CH4), R24.2, R25.2
AGND: C17.-, C18.-, C21.-, IC7.4 (GND), J3.1, JP2.2, JP3.2, L3.2, R20.2, R21.2, VR1.1, VR2.1
BAT-V: C6.+, C9.+, IC1.8 (CH7), IC5.3 (VBAT), IC8.1 (S), IC8.2 (S), IC8.3 (S), JP4.2, R6.2, SJ1.2
BAT_CHAG: R7.1, U$1.P1_16 (GPIO23)
BL_CTRL: LCD1.40 (BL_CTRL), U$1.P1_12 (PWM0/GPIO18)
DATA: IC3.3 (SCK), R26.1, U$1.P1_15 (GPIO22)
DC-IN: D2.A, F1.P$1 (1), Q3.2 (IN), R4.1, ZD1.A
DC-V: C26.1, D1.D (AC), IC1.7 (CH6), R4.2, R5.2
GND: C1.2, C6.-, C7.2, C9.-, C10.2, C11.2, C13.2, C14.-, C15.2, C16.2, C19.2, C20.2, C26.2, C27.2, C28.2, C51.2, C52.2, C58.2, D1.G (A), D4.A, IC4.3 (GND), IC5.2 (VSS), IC6.3 (PGND), IC6.4 (PGND), IC6.5 (PGND), IC6.8 (SYNC), IC6.11 (GND), IC6.TH_PAD (POW_PAD), J1.1, JP1.2, JP6.2, JP7.3, L3.1, L5.1, LCD1.2 (GND), LCD1.19 (GND), LCD1.22 (GND), LCD1.39 (GND), Q3.1 (GND), R5.1, R9.1, R12.1, R13.2, R19.1, SW1.1, SW3.2, U1.13 (GND), U$1.P1_6 (GND), U$1.P1_9 (GND), U$1.P1_14 (GND), U$1.P1_20 (GND), U$1.P1_25 (GND), U$1.P5_7 (GND), U$1.P5_8 (GND), U$1.P6_2 (GND), ZD1.C (K)
GND1: C2.2, C3.1, C4.2, C5.1, C29.2, C30.2, C31.2, C53.2, C54.-, C55.2, D6.G (A), D7.G (A), IC1.9 (GND), IC1.11 (COM), IC1.12 (A0), IC1.13 (A1), IC2.3 (GND), IC2.4 (CSB), IC2.5 (CSB1), IC3.1 (GND), IC9.1 (GND), JP5.7, L5.2, R23.1, R25.1
GPIO30: U$1.P5_5 (GPIO30)
GPIO31: U$1.P5_6 (GPIO31)
I2C0_SCL/GPIO29: U$1.P5_4 (I2C0_SCL/GPIO29)
I2C0_SDA/GPIO28: U$1.P5_3 (I2C0_SDA/GPIO28)
LCD_CS: LCD1.4 (LCDB_CS), U$1.P1_24 (GPIO8/SPI0_CE0)
LCD_RST: LCD1.15 (RESET), U$1.P1_22 (GPIO25)
LCD_SCK: LCD1.3 (LCDB_SCK), LCD1.33 (TP_SCK), U$1.P1_23 (GPIO11/SPI0_SLCK)
LCD_SDI: LCD1.6 (LCDB_SDI), LCD1.34 (TP_SDI), U$1.P1_19 (GPIO10/SPI0_MOSI)
LCD_SDO: LCD1.5 (LCDB_SDO), LCD1.35 (TP_SDO), U$1.P1_21 (GPIO9/SPI0_MISO)
LEFT: J3.2, VR1.3
L_BAT: R28.1, U$1.P1_18 (GPIO24)
unnamed: C28.1, SW3.1, U$1.P1_7 (GPIO4/GPCLK0)
unnamed: C8.2, D2.C, IC4.EX_PAD (VIN), R8.2
unnamed: IC4.6 (FB), R18.1, R19.2
unnamed: C12.2, IC4.2 (BST)
unnamed: F2.P$1 (1), JP4.1, SJ1.1
unnamed: C27.1, IC8.4 (G), J1.2, R6.1
unnamed: D3.A, R14.1
unnamed: C12.1, R15.1
unnamed: D4.C, IC4.1 (LX), L2.2, R15.2
unnamed: IC4.5 (COMP), R10.2
unnamed: C8.1, R10.1
unnamed: JP5.5, R24.1
unnamed: C1.1, SW1.2, U$1.P6_1 (RESET)
unnamed: JP5.4, R22.1
unnamed: D5.K (C), R17.2
unnamed: F2.P$2 (2), JP1.1
unnamed: IC6.7 (LBI), R11.1, R12.2
unnamed: IC4.8 (EN), R8.1
unnamed: IC4.4 (FSW), R13.1
unnamed: C2.1, IC1.10 (VREF)
unnamed: Q2.G (GATE), Q3.3 (OUT), R1.2
unnamed: C11.1, IC4.7 (SS)
unnamed: C14.+, D3.K (C), IC5.4 (VDD), Q2.D (DRAIN)
unnamed: IC5.1 (STAT), R7.2, R14.2
unnamed: C7.1, C10.1, IC6.6 (VBAT), IC6.9 (EN), IC8.5 (D), IC8.6 (D), IC8.7 (D), IC8.8 (D), L1.2, R11.2
unnamed: IC6.10 (LBO), R16.1, R17.1, R28.2
unnamed: IC6.1 (SW), IC6.2 (SW), L1.1
unnamed: IC5.5 (PROG), R9.2
unnamed: C17.+, IC7.8 (IN1-)
unnamed: C18.+, IC7.5 (IN2-)
unnamed: IC7.6 (IN2+), VR2.2
unnamed: IC7.7 (IN1+), VR1.2
unnamed: C22.+, IC7.1 (OUT1)
unnamed: C23.+, IC7.3 (OUT2)
unnamed: C22.-, C24.2, JP2.1
unnamed: C23.-, C25.2, JP3.1
unnamed: C24.1, R20.1
unnamed: C25.1, R21.1
RELAY1: IC10.5, IC10.6, JP7.2, ZD3.C (K)
RELAY2: IC10.7, IC10.8, JP7.1, ZD2.C (K)
RIGHT: J3.3, VR2.3
RXI: U1.1 (TXD), U$1.P1_10 (UART0_RXD/GPIO15)
SCK: IC3.2 (DATA), R27.1, U$1.P1_13 (GPIO27)
SCL1: IC1.14 (SCL), IC2.8 (SCLK), R3.1, U$1.P1_5 (GPIO3/I2C1_SCL)
SDA1: IC1.15 (SDA), IC2.7 (SDA), R2.1, U$1.P1_3 (GPIO2/I2C1_SDA)
TEMP-V: IC1.6 (CH5), IC9.2 (VOUT)
TP_CS: LCD1.32 (TP_CS), U$1.P1_26 (GPIO7/SPI0_CE1)
TP_IRQ: LCD1.36 (TP_IRQ), U$1.P1_11 (UART0_RTS/GPIO17)
TXO: U1.2 (RXD), U$1.P1_8 (UART0_TXD/GPIO14)

Notes on the sheet:
+5 Voltage Step Up Regulator
1Cell Li-po Battery Chager
SPI Touch TFT-LCD
+5 Voltage Step Down Regulator
ADDRESS: 0xEE(8bit)
PRESSOR SENSOR
TEMPERATURE &
HUMIDITY SENSOR
12BIT 8CH I2C-BUS ADC
MODULE
RASPBERRY PI I/O
ADDRESS: 0x90(8bit)
TEMP SENSOR
측정레인지 : -30~100℃
1W STEREO AUDIO AMP
BLUETOOTH

Board: 2 copper layers, 87.0 x 56.0 mm, 111 parts (0 on the bottom side), 74 nets.

Notices in the files:
parts and their libraries:
raspberrypi: This library stands under the CERN Open Hardware Licence.
