# Repository mocona05/Raspberry-Pi-LoRa-Shield (continued)

## EAGLE design PCB/Raspberry_Pi/DP_pwer_controler_v2.brd

Parts:
BAT1: MS621
C1, C7, C9, C13, C15, C16, C17, C24, C25, C26: 0.1uF; C0603
C2, C3: 12.5pF; C0603
C4, C6: 10nF; C0603
C5, C8, C14: 4.7uF/10V; C2012/T
C10, C11, C18, C19, C21, C22: 1uF; C0603
C12: 470pF; C0603
C20: 6.8uF; C0805
C23: 2.2uF; C0805
D1: BAT54C; SOT23
F1: FSMD300R; 1812L
IC1: STM32F051XSTM32F051X; TQFP48
IC2: MIC5219-3.3BM5; SOT23-5
JP1: SWD; 1X04M
JP2: RESET; MA02-1-MOL
L1, L2: BEAD; L0603
LCD1: SSD1306_0.96_OLED; SSD1306_0.96OLED_BUTTOM
LED1, LED2, LED3: LEDSMD-1608; LED-1608
Q1: 32.768k; MC-306
Q2: 8MHz; CSTLA_X
Q3, Q4: DTC114EUA; SC59-BEC
Q5: CXDM4060P; SOT89
R1, R2, R3: 1k; R0603
R4, R5, R6, R7, R9, R10, R11, R12, R13: 10k; R0603
R8: 11k; R0603
R14, R15, R16, R18, R19, R20: 4.7k; R0603
R17: 100k; R0603
SW1, SW2, SW3, SW4, SW5: ITS-1105
USB1: MOLEX-47346-0001; MOLEX-47364-0001
X1: RASPI_BOARD_B+#_F; RASPI_BOARD_B+_FULL
ZD1: SM6T6V8CAY; SMB
ZD2: RD10S; DSMM

Connections:
3V3: R11.2, R12.2, R13.2, X1.1 (3V3A)
3V3B: X1.17 (3V3B)
5V_ADC: C4.2, IC1.10 (PA0), R4.2, R5.1
+3V3: C1.1, C7.1, C8.+, C9.1, C10.1, C13.2, C14.+, C18.1, C19.1, D1.G (1), IC1.24 (VDD_1), IC1.48 (VDD_2), IC2.5 (OUT), JP1.1, L2.1, LCD1.5 (C1N), LCD1.8 (VSS), R6.2, R9.2, R10.2, R15.2, R16.2, R18.2, R19.2, R20.2
+5V: Q5.2 (D), Q5.2@1 (D), X1.2 (5V0A), X1.4 (5V0B), ZD2.C
+UB: C11.2, C15.1, F1.P$1 (1), IC2.1 (IN), IC2.3 (EN), Q5.1 (S), R4.1, R14.2
AGND: C5.-, C6.2, IC1.8 (VSSA), L1.2
BTN1: C26.1, IC1.39 (PB3), R20.1, SW5.3, SW5.4
BTN2: C25.1, IC1.40 (PB4), R19.1, SW4.3, SW4.4
BTN3: C17.1, IC1.41 (PB5), R16.1, SW2.3, SW2.4
GND: BAT1.-, C1.2, C2.1, C3.1, C4.1, C7.2, C8.-, C9.2, C10.2, C11.1, C12.1, C13.1, C14.-, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C23.2, C24.2, C25.2, C26.2, IC1.23 (VSS_1), IC1.47 (VSS2), IC2.2 (GND), JP1.3, JP2.2, L1.1, LCD1.7 (NC), LCD1.9 (VDD), LCD1.10 (BS0), LCD1.11 (BS1), LCD1.20 (D2/I2C_SDA), LCD1.21 (D3), LCD1.22 (D4), LCD1.23 (D5), LCD1.24 (D6), LCD1.28 (VCC), LED1.C, LED2.C, LED3.C, Q2.2 (GND), Q3.1 (GND), Q4.1 (GND), R5.2, R7.2, R17.1, SW1.1, SW1.2, SW2.1, SW2.2, SW3.1, SW3.2, SW4.1, SW4.2, SW5.1, SW5.2, USB1.4, X1.6 (GND_A), X1.9 (GND_B), X1.14 (GND_C), X1.20 (GND_D), X1.25 (GND_E), X1.30 (GND_F), X1.34 (GND_G), X1.39 (GND_H), ZD1.C (K), ZD2.A
LCD_CS: IC1.14 (PA4), LCD1.12 (BS2)
LCD_D/C: IC1.16 (PA6), LCD1.14 (!RES)
LCD_RST: IC1.18 (PB0), LCD1.13 (!CS)
LED1: IC1.28 (PB15), R1.1
LED2: IC1.29 (PA8), R2.1
LED3: IC1.30 (PA9), R3.1
unnamed: C12.2, IC2.4 (BP)
unnamed: F1.P$2 (2), USB1.1, ZD1.A
unnamed: IC1.7 (NRST), R6.1
unnamed: JP2.1, Q3.3 (OUT)
unnamed: C5.+, C6.1, IC1.9 (VDDA), L2.2
unnamed: BAT1.+, D1.S (2), R8.2
unnamed: IC1.3 (PC14=>OSC32), Q2.3 (OUT)
unnamed: LCD1.25 (D7), R17.2
unnamed: IC1.44 (BOOT0), R7.1
unnamed: LED1.A, R1.2
unnamed: LED2.A, R2.2
unnamed: LED3.A, R3.2
unnamed: C21.1, LCD1.2 (C2P)
unnamed: C21.2, LCD1.1 (NC(GND))
unnamed: C22.2, LCD1.3 (C2N)
unnamed: C22.1, LCD1.4 (C1P)
unnamed: C20.1, LCD1.26 (IREF)
unnamed: C23.1, LCD1.27 (VCOMH)
unnamed: Q4.3 (OUT), Q5.3 (G), R14.1
unnamed: D1.D (3), IC1.1 (BAT), R8.1
unnamed: IC1.4 (PC15<=OSC32), Q2.1 (IN)
unnamed: C3.2, IC1.5 (PF0/OSC<=), Q1.1
unnamed: C2.2, IC1.6 (PF1/OSC=>), Q1.4 (2)
POWER_ON: C16.1, IC1.19 (PB1), R15.1, SW1.3, SW1.4
RPY-RST: IC1.13 (PA3), Q3.2 (IN)
RPY_CTRL1: IC1.21 (PB10), R13.1, X1.11 (GPIO17)
RPY_CTRL2: IC1.22 (PB11), R11.1, X1.7 (GPIO04)
RPY_POW: IC1.45 (PB8), Q4.2 (IN)
RXI1: IC1.43 (PB7), X1.8 (TXD)
SHUT_DOWN: C24.1, IC1.20 (PB2), R18.1, SW3.3, SW3.4
SPI1_MOSI: IC1.17 (PA7), LCD1.18 (D0/SPI_SCLK/I2C_SCK), LCD1.19 (D1/SPI_SDIN/I2C_SDA)
SPI1_SCK: IC1.15 (PA5), LCD1.17 (E/RD)
SWCLK: IC1.37 (PA14), JP1.4, R10.1
SWDIO: IC1.34 (PA13), JP1.2, R9.1
TXO1: IC1.42 (PB6), X1.10 (RXD)
W-DOG: IC1.12 (PA2), R12.1, X1.40 (GPIO21)

Notes on the sheet:
POWER CONTROLER V1
https://webench.ti.com/webench5/power/webench5.cgi?app=filterarchitect&origin=ti_panel&filterType=Lowpass
POWER IN
USB POWER OUT
RASPBERRY PI
3.3V REGULATOR
PCM5102

Board: 2 copper layers, 65.0 x 56.0 mm, 73 parts (8 on the bottom side), 52 nets.

## EAGLE design PCB/RPI_LoRa_v1.2.brd

Parts:
C1, C4, C5, C11, C12, C19, C21, C22: 0.1uF; C0603
C2, C6, C9, C13: 10nF; C0603
C3, C8, C16, C17, C23: 1uF; C0603
C7, C10: 1nF; C0603
C14, C15: DNP; C0603
C18: 470pF; C0603
C20: 4.7uF/10V; C2012/T
IC1: LT1634ACS-1.25; MS8
IC2: CMWX1ZZABZ
IC3: AD8495; MSOP8
IC4: ETH-01S-D; SENSOR
J$1: SMA_EDGE; SMA-EDGE
JP1: SWD; 1X04M
JP2: TC1; ED350V-02P
JP3: MA03-15267; MOLEX5267-03
L1: L_0603; L0603
LED1: LEDSMD-1608; LED-1608
LGA101: CCS811
Q1: MMBT3904; SOT23
Q2: DMG2305UX; SOT23
Q3: DMMT5401; SOT23-6L
R1, R2, R4, R5, R15: 10k; R0603
R3: 18k; R0603
R6, R8, R11: 10kF; R0603
R7: 1M; R0603
R9: 1k; R0603
R10: 30kF; R0603
R12, R13: 22; R0603
R14: 100; R0603
R16: 36k; R0603
R17: 1.5k; R0603
R18, R23, R24, R25: 4.7k; R0603
R19: 470k; R0603
R22: 47k; R0603
U1: MIC5219-3.3BM5; SOT23-5
USB1: MOLEX-47346-0001; MOLEX-47364-0001
X11: RPI-ZERO; RASP_PI_ZERO_BOARD_FULL
ZD1: TPD2E001DZDR; DZD

Connections:
3V3: C3.1, C4.1, C5.1, C6.1, C8.1, C12.1, C13.1, C19.2, C20.+, C22.2, C23.1, IC2.5 (VDD_MCU), IC2.6 (VDD_RF), IC2.32 (VREF+), IC2.48 (VDD_TCXO), IC4.P$4 (VDD), JP1.1, LGA101.6 (VDD), Q1.D (OUT), R1.2, R2.2, R4.2, R15.2, R18.2, R23.2, R24.2, R25.2, U1.5 (OUT)
+1.25V_REF: IC1.6 (VOUT), IC3.2 (REF), R3.2
+5V: C11.1, C17.2, IC3.7 (V+), Q2.S (SOURCE), Q3.5 (E2), R3.1, U1.1 (IN), U1.3 (EN), X11.2 (5V0), X11.4 (5V0)
ANTL: C15.1, J$1.SIG (SIGNAL), L1.1
CO2_NINT: IC2.14 (PB15/SPI2_MOSI), LGA101.3 (NINT)
CO2_NRESET: IC2.15 (PB14/SPI2_MISO), LGA101.2 (NRESET), R18.1
CO2_NWAKE: IC2.16 (PB13/SPI2_SCK), LGA101.7 (NWAKE), R23.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, C19.1, C20.-, C21.1, C22.1, C23.2, IC1.4 (GND), IC2.3 (GND), IC2.7 (GND), IC2.25 (GND), IC2.27 (GND), IC2.44 (GND), IC2.PAD (GND), IC3.3 (V-), IC4.P$6 (VSS), J$1.GND@0 (GND), J$1.GND@1 (GND), J$1.GND@2 (GND), J$1.GND@3 (GND), JP1.3, JP3.3, LED1.C, LGA101.1 (ADDR), LGA101.EP (GND), R5.1, R7.1, R11.1, R16.1, R19.1, R22.1, U1.2 (GND), USB1.5, X11.6 (GND), X11.9 (GND), X11.14 (GND), X11.20 (GND), X11.25 (GND), X11.30 (GND), X11.34 (GND), X11.39 (GND), ZD1.1 (GND)
I2C1_SCL: IC2.39 (PB6/LPTIM1_ETR), IC4.P$1 (SCL), LGA101.10 (SCL), R25.1
I2C1_SDA: IC2.38 (PB7/LPTIM1_IN2), IC4.P$2 (SDA), LGA101.9 (SDA), R24.1
unnamed: C18.2, U1.4 (BP)
unnamed: LGA101.4 (PWM), LGA101.5 (SENSE)
unnamed: R13.1, USB1.3
unnamed: R12.1, USB1.2
unnamed: Q2.G (GATE), Q3.4 (C2), R22.2
unnamed: LED1.A, R9.1
unnamed: IC2.34 (MCU_NRST), R4.1
unnamed: IC2.40 (PB5/LPTIM1_INI1), R9.2
unnamed: Q3.1 (C1), Q3.2 (B1), Q3.3 (B2), R19.2
unnamed: C21.2, IC4.P$3 (VC)
unnamed: C14.1, IC2.26 (ANT), L1.2
unnamed: IC2.43 (BOOT0), R5.2
unnamed: Q1.G (IN), R14.2, R15.1, R16.2
unnamed: C9.2, C10.1, IC3.1 (-IN), R8.2
unnamed: C7.1, C9.1, IC3.8 (+IN), R6.2
unnamed: JP2.2, R7.2, R8.1
unnamed: JP2.1, R6.1
unnamed: IC3.5 (SENS), IC3.6 (OUT), R10.1
unnamed: Q1.S (GND), R17.2
NC: IC4.P$5 (NC)
RXI1: IC2.18 (PA10/RX1), X11.8 (TXD0/GPIO14)
RXI2: IC2.23 (PA3/ADC3), JP3.1
SWCLK: IC2.42 (PA14/SWCLK), JP1.4, R2.1
SWDIO: IC2.41 (PA13/SWDIO), JP1.2, R1.1
TC1_ADC: C16.1, IC2.22 (PA4/ADC4/DAC1), R10.2, R11.2
TXO1: IC2.19 (PA9/TX1), X11.10 (RXD0/GPIO15)
TXO2: IC2.24 (PA2/ADC2), JP3.2
USB_DM: IC2.2 (PA11/USB-), R12.2, ZD1.3 (IO2)
USB_DP: IC2.1 (PA12/USB+), R13.2, R17.1, ZD1.2 (IO1)
USB_EN: IC2.17 (PB12/SPI2_NSS), R14.1
VPP: C1.1, C2.1, IC2.4 (VDD_USB), Q2.D (DRAIN), Q3.6 (E1), USB1.1, ZD1.4 (VCC)

Notes on the sheet:
3.3V REGULATOR
USB POWER INPUT
온도 센서
K-Type Range = -180°C to 1200°C
1.V REF = -200°C to
0.9V REF = -180°C to
0V REF = 0°C to
THERMO COUPLE K-TYPE
1.25V REF = -250°C to 1200°C
IDAEL DIODE
raspberry zero
MCU
STLink
ADDRESS:0x44(7bit)
CO2 Sensor

Board: 2 copper layers, 65.0 x 30.2 mm, 64 parts (0 on the bottom side), 40 nets.

## EAGLE design PCB/RPI_LoRa_v1.1.brd

Parts:
C1, C3: 1nF; C0603
C2, C6, C11, C15: 10nF; C0603
C4, C5, C8, C9, C13, C14, C17, C18, C19, C21, C24, C28, C29: 0.1uF; C0603
C7, C10, C12, C22: 1uF; C0603
C16, C20: DNP; C0603
C23: 470pF; C0603
C25: 4.7uF/10V; C2012/T
IC1: LT1634ACS-1.25; MS8
IC2: AD8495; MSOP8
IC3: CMWX1ZZABZ
IC4: MAX3232CPW; PW_R-PDSO-G16
IC5: ETH-01S-D; SENSOR
J$1: SMA_EDGE; SMA-EDGE
JP1: TC1; ED350V-02P
JP2: SWD; 1X04M
JP4: RS232C_MCU; MOLEX5267-03
JP5: PINHD-1X55X2MM; 1_05X2MM
L1: L_0603; L0603
L2: BEAD; L0603
LED1: LEDSMD-1608; LED-1608
Q1: DMG2305UX; SOT23
Q2: DMMT5401; SOT23-6L
R1: 18k; R0603
R2, R3, R7, R8: 10k; R0603
R4, R6, R10: 10kF; R0603
R5: 1M; R0603
R9: 30kF; R0603
R11: 1k; R0603
R12, R13: 22; R0603
R14: 1.5k; R0603
R15: 470k; R0603
R17: 47k; R0603
R19, R20: 2.2k; R0603
U1: MIC5219-3.3BM5; SOT23-5
USB1: MOLEX-47346-0001; MOLEX-47364-0001
X11: RPI-ZERO; RASP_PI_ZERO_BOARD_FULL

Connections:
3V3: C7.1, C8.1, C9.1, C11.1, C12.1, C13.1, C15.1, C18.1, C21.2, C24.2, C25.+, C29.2, IC3.5 (VDD_MCU), IC3.6 (VDD_RF), IC3.32 (VREF+), IC3.48 (VDD_TCXO), IC4.16 (VCC), IC5.P$4 (VDD), JP2.1, JP5.1, R2.2, R3.2, R7.2, R14.2, R19.2, R20.2, U1.5 (OUT)
+1.25V_REF: IC1.6 (VOUT), IC2.2 (REF), R1.2
+5V: C4.1, C22.2, IC2.7 (V+), Q1.S (SOURCE), Q2.5 (E2), R1.1, U1.1 (IN), U1.3 (EN), X11.2 (5V0), X11.4 (5V0)
ANTL: C20.1, J$1.SIG (SIGNAL), L1.1
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C16.2, C20.2, C21.1, C22.1, C23.1, C24.1, C25.-, C28.1, C29.1, IC1.4 (GND), IC2.3 (V-), IC3.3 (GND), IC3.7 (GND), IC3.25 (GND), IC3.27 (GND), IC3.44 (GND), IC3.PAD (GND), IC4.15 (GND), IC5.P$6 (VSS), J$1.GND@0 (GND), J$1.GND@1 (GND), J$1.GND@2 (GND), J$1.GND@3 (GND), JP2.3, JP5.5, L2.2, LED1.C, R5.1, R8.1, R10.1, R15.1, R17.1, U1.2 (GND), USB1.5, X11.6 (GND), X11.9 (GND), X11.14 (GND), X11.20 (GND), X11.25 (GND), X11.30 (GND), X11.34 (GND), X11.39 (GND)
I2C1_SCL: IC3.39 (PB6/LPTIM1_ETR), IC5.P$1 (SCL), R19.1
I2C1_SDA: IC3.38 (PB7/LPTIM1_IN2), IC5.P$2 (SDA), R20.1
IO1: IC3.37 (PB2/LPTIM1_OUT), JP5.2
IO2: IC3.45 (PH1-OSC_OUT), JP5.3
IO3: IC3.46 (PH0-OSC_IN), JP5.4
unnamed: C23.2, U1.4 (BP)
unnamed: JP4.3, L2.1
unnamed: R13.1, USB1.3
unnamed: R12.1, USB1.2
unnamed: Q1.G (GATE), Q2.4 (C2), R17.2
unnamed: LED1.A, R11.1
unnamed: IC3.34 (MCU_NRST), R7.1
unnamed: IC3.40 (PB5/LPTIM1_INI1), R11.2
unnamed: Q2.1 (C1), Q2.2 (B1), Q2.3 (B2), R15.2
unnamed: C28.2, IC5.P$3 (VC)
unnamed: C19.1, IC4.5 (C2-)
unnamed: C19.2, IC4.4 (C2+)
unnamed: C18.2, IC4.2 (V+)
unnamed: C16.1, IC3.26 (ANT), L1.2
unnamed: IC3.43 (BOOT0), R8.2
unnamed: C14.2, IC4.6 (V-)
unnamed: C17.2, IC4.1 (C+)
unnamed: C17.1, IC4.3 (C1-)
unnamed: IC4.13 (RIN1), JP4.2
unnamed: IC4.14 (DOUT1), JP4.1
unnamed: C2.2, C3.1, IC2.1 (-IN), R6.2
unnamed: C1.1, C2.1, IC2.8 (+IN), R4.2
unnamed: JP1.2, R5.2, R6.1
unnamed: JP1.1, R4.1
unnamed: IC2.5 (SENS), IC2.6 (OUT), R9.1
NC: IC5.P$5 (NC)
RXI1: IC3.18 (PA10/RX1), X11.8 (TXD0/GPIO14)
RXI2: IC3.23 (PA3/ADC3), IC4.12 (ROUT1)
SWCLK: IC3.42 (PA14/SWCLK), JP2.4, R3.1
SWDIO: IC3.41 (PA13/SWDIO), JP2.2, R2.1
TC1_ADC: C10.1, IC3.22 (PA4/ADC4/DAC1), R9.2, R10.2
TXO1: IC3.19 (PA9/TX1), X11.10 (RXD0/GPIO15)
TXO2: IC3.24 (PA2/ADC2), IC4.11 (DIN1)
USB_DM: IC3.2 (PA11/USB-), R12.2
USB_DP: IC3.1 (PA12/USB+), R13.2, R14.1
VPP: C5.1, C6.1, IC3.4 (VDD_USB), Q1.D (DRAIN), Q2.6 (E1), USB1.1

Notes on the sheet:
3.3V REGULATOR
RS232C
USB POWER INPUT
환경측정 센서
K-Type Range = -180°C to 1200°C
1.V REF = -200°C to
0.9V REF = -180°C to
0V REF = 0°C to
THERMO COUPLE K-TYPE
1.25V REF = -250°C to 1200°C
IDAEL DIODE
raspberry zero
MCU
Antena
ADDRESS:0x44(7bit)

Board: 2 copper layers, 65.0 x 30.2 mm, 63 parts (0 on the bottom side), 45 nets.
